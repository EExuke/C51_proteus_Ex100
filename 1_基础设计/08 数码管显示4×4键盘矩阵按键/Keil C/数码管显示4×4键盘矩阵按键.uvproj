# Keil uVision project 数码管显示4×4键盘矩阵按键.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 数码管显示4×4键盘矩阵按键 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Text1.C
