# Keil uVision project TIMER0、TIMER1、TIMER2实现外部信号计数与显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: TIMER0、TIMER1、TIMER2实现外部信号计数与显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Text1.c
