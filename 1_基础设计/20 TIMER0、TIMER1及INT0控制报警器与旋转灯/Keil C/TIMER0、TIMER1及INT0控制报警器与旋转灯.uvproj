# Keil uVision project TIMER0、TIMER1及INT0控制报警器与旋转灯.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: TTIMER0、TIMER1及INT0控制报警器与旋转灯 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Text1.c
