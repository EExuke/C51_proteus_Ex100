# Keil uVision project 数码管BCD解码驱动器CD4511与DM7447应用.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C2051 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x7FF) CLOCK(24000000)
  output: 数码管BCD解码驱动器CD4511与DM7447应用 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Text1.c
