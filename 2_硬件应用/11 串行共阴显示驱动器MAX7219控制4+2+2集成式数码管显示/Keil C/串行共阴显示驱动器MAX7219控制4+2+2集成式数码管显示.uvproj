# Keil uVision project 串行共阴显示驱动器MAX7219控制4+2+2集成式数码管显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 串行共阴显示驱动器MAX7219控制4+2+2集成式数码管显示 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Text1.c
